# Keil uVision project stm32f103.uvprojx, settings and files
target Template (6220000::V6.22::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Users;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\uart1;..\..\Drivers\SYSTEM\sys;..\..\Drivers\BSP\led;..\..\Drivers\BSP\motor;..\..\Drivers\BSP\bluetooth;..\..\Drivers\BSP\speed;..\..\Drivers\BSP\oled;..\..\Drivers\BSP\esp8266;..\..\Drivers\SYSTEM\timer;..\..\Drivers\BSP\follow;..\..\Drivers\BSP\hcsr04;..\..\Drivers\BSP\sg90;..\..\Drivers\BSP\track;..\..\Drivers\BSP\voice
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f101xb.s
  group User
    ../../Users/: main.c stm32f1xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/BSP
    ../../Drivers/BSP/led/: led.c
    ../../Drivers/BSP/motor/: motor.c
    ../../Drivers/BSP/speed/: speed.c
    ../../Drivers/BSP/oled/: oled.c
    ../../Drivers/BSP/esp8266/: esp8266.c
    ../../Drivers/BSP/follow/: follow.c
    ../../Drivers/BSP/hcsr04/: hcsr04.c
    ../../Drivers/BSP/sg90/: sg90.c
    ../../Drivers/BSP/track/: track.c
    ../../Drivers/BSP/voice/: voice.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/uart1/: uart1.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/timer/: timer.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
